.inc rram/rram_64_64_freepdk45.sp
.inc sp/1t1r.sp
